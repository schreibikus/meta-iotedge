require recipes-devtools/rust/rust-tools-cross-canadian.inc
require rust-source.inc
require rust-snapshot.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/rust:"

