require ../rust/rust-source.inc
require ../rust/rust-snapshot.inc
require recipes-devtools/cargo/cargo.inc
BBCLASSEXTEND = "native nativesdk"
